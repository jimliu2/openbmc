SNOOP_DEVICE:npcm8xx = "npcm7xx-lpc-bpc0"
