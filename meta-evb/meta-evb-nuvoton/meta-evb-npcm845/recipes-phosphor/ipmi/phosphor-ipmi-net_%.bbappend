RMCPP_IFACE:evb-npcm845 = "eth0"
