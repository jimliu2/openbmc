FILESEXTRAPATHS:prepend:evb-npcm845 := "${THISDIR}/${PN}:"
