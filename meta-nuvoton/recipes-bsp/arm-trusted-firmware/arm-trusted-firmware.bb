ATF_VERSION = "1.5"
SRCREV = "abd7a61463dedcded06af2d8e11ccef57101b378"
BRANCH = "nuvoton"
LIC_FILES_CHKSUM = "file://license.rst;md5=1dd070c98a281d18d9eefd938729b031"

include arm-trusted-firmware.inc
